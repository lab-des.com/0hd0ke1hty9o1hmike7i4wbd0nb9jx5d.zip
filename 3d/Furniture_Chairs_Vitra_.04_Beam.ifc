Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2021-09-01T12:55:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.3.3.18 - Alternate UI 18.3.3.18
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 01 12:55:35 2021 * Host: Avocado-PC * Database: D:\Jocuri\TEMP\{28EAC7C8-4843-4819-99CD-BB42CEA56471}\ifc * Database version: 5507 * Database creation date: Wed Sep 01 12:55:33 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 01 12:55:33 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 01 12:55:33 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFurnishingElement: .04 beam seating, Furniture_Chairs_Vitra_.04_Beam:.04 beam seating:428916
In: Level 1
Type - Material: Basic dark powder-coated 30, Dark Green
Pset_ManufacturerTypeInformation - ModelReference: n/a; Manufacturer: Vitra
